# Keil uVision project Project.uvprojx, settings and files
target Project-F19 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --debug
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include;..\drivers\include;..\peripherals\include
  asm misc: --debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c main.h project_hardware_init.c project_hardware_init.h project_interrupts.c project_interrupts.h hw3_staff.c project_images.c ps2-new.c hw3.c
  group drivers
    ../ece353_project_game/drivers/c/: adc.c gpio_port.c i2c.c pc_buffer.c spi.c timers.c uart.c
    ./drivers/c/: gptimer.c
    ./drivers/include/: adc.h
  group peripherals
    ../ece353_project_game/peripherals/c/: accel.c eeprom.c ft6x06.c launchpad_io.c lcd.c serial_debug.c spi_select.c ws2812b.s
    ./peripherals/c/: ece353_images.c lcd_images.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
